options:
  parameters:
    author: Codrina Lisaru
    generate_options: qt_gui
    id: Apl4_Receptor_Analizor_cu_salvare_date_Codrina_Lisaru
    output_language: python
    title: Receptor/Analizor cu salvare date
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Display bandwidth in Hz
    orient: Qt.Horizontal
    start: '1'
    step: '100'
    stop: 100e6
    value: '4800'
  states: {}
- name: Center_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Center frequency in Hz
    orient: Qt.Horizontal
    start: 100e3
    step: step
    stop: 6e9
    value: '126944900'
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RF Gain in dB
    orient: Qt.Vertical
    start: '0'
    step: '0.5'
    stop: '50'
    value: '40'
  states: {}
- name: receiverchooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Choose Receiver Type
    labels: '["Spectrum analyzer without data record","Spectrum analyzer with data record","Mono FM Receiver without data record","Mono FM Receiver with data record","Stereo FM Receiver without data record","Stereo FM Receiver with data record","AM receiver without data record","AM receiver with data record","NBFM receiver without data record","NBFM receiver with data record"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10]'
    type: int
    value: '0'
  states: {}
- name: recordsamprate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,4,1,1
    label: Wav samp rate
    label0: 16 kHz
    label1: 22.05 kHz
    label2: 32 kHz
    label3: 44.1 kHz
    label4: 48 kHz
    num_opts: '5'
    option0: '16000'
    option1: '22050'
    option2: '32000'
    option3: '44100'
    option4: '48000'
    type: int
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Squelch [NBFM Use Only]
    orient: Qt.Horizontal
    start: '-110'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: step
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Center freq step size in Hz
    orient: Qt.Horizontal
    start: '10'
    step: '1'
    stop: '200000'
    value: '100'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,1
    label: Bits per sample - wav file record
    label0: 8 bits
    label1: 16 bits
    label2: 32 bits
    label3: 64 bits
    num_opts: '4'
    option0: '8'
    option1: '16'
    option2: '32'
    option3: '64'
    type: int
    value: '8'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: 'Frequency Start for RTL-SDR blue stick is 24 MHz and stop frequency '
    type: string
    value: 1.766 GHz
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 500e3
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 500e3
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    quad_rate: 500e3
  states: {}
- name: analog_wfm_rcv_pll_0_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0_1
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_1_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: M:\OneDrive\02_Master\2_2\02_Disertatie\GNU Radio implementation\Aplicatia 4 - Receptor_Analizor cu salvare de date\filename
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '10'
    output_index: receiverchooser
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: variable_qtgui_chooser_0
    file: M:\OneDrive\02_Master\2_2\02_Disertatie\GNU Radio implementation\Aplicatia 4 - Receptor_Analizor cu salvare de date\AMRecordedData.wav
    samp_rate: recordsamprate
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: variable_qtgui_chooser_0
    file: M:\OneDrive\02_Master\2_2\02_Disertatie\GNU Radio implementation\Aplicatia 4 - Receptor_Analizor cu salvare de date\NBFMRecordedData.wav
    samp_rate: recordsamprate
  states: {}
- name: blocks_wavfile_sink_0_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: variable_qtgui_chooser_0
    file: M:\OneDrive\02_Master\2_2\02_Disertatie\GNU Radio implementation\Aplicatia 4 - Receptor_Analizor cu salvare de date\MonoRecorder.wav
    samp_rate: recordsamprate
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: variable_qtgui_chooser_0
    file: M:\OneDrive\02_Master\2_2\02_Disertatie\GNU Radio implementation\Aplicatia 4 - Receptor_Analizor cu salvare de date\SpectrumAnalyzerData.wav
    nchan: '2'
    samp_rate: recordsamprate
  states: {}
- name: blocks_wavfile_sink_1_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: variable_qtgui_chooser_0
    file: M:\OneDrive\02_Master\2_2\02_Disertatie\GNU Radio implementation\Aplicatia 4 - Receptor_Analizor cu salvare de date\StereoRecorder.wav
    nchan: '2'
    samp_rate: recordsamprate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '10'
    gain: '10'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '7500'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '10'
    gain: '10'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '7500'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: Center_frequency
    gain0: RF_Gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    gui_hint: tab_widget@0:7,0,1,2
    legend: 'False'
    name: '"Real time spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    gui_hint: 'tab_widget@1: 7,0,1,2'
    legend: 'False'
    name: '"Real time spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    gui_hint: 'tab_widget@2: 7,0,1,2'
    name: '"Real time spectrum"'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 'tab_widget@2: 9,0,1,2'
    legend: 'False'
    name: '"Time domain representation"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tab_widget@0:9,0,1,2
    legend: 'False'
    name: '"Time domain representation"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tab_widget@1:9,0,1,2
    legend: 'False'
    name: '"Time domain representation"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    gui_hint: 'tab_widget@0: 8,0,1,2'
    legend: 'False'
    name: '"Waterfall (Spectrogram)"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    gui_hint: 'tab_widget@1: 8,0,1,2'
    name: '"Waterfall (Spectrogram)"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    gui_hint: 'tab_widget@2: 8,0,1,2'
    legend: 'False'
    name: '"Waterfall (Spectrogram)"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/500e3)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/500e3)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/500e3)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/500e3)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(500e3/1e4)
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: int(500e3/1e4)
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: tab_widget
  id: qtgui_tab_widget
  parameters:
    gui_hint: 6,0,1,5
    label0: Spectrum Analyzer without data record
    label1: Spectrum Analyzer with data record
    label2: Different type of receiver
    num_tabs: '3'
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_nbfm_rx_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_nbfm_rx_0_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [analog_wfm_rcv_0_0, '0', rational_resampler_xxx_1_0, '0']
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_0_0_0_1, '0']
- [analog_wfm_rcv_pll_0_0, '0', blocks_multiply_const_vxx_0_0_1_0, '0']
- [analog_wfm_rcv_pll_0_0, '1', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_1, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_1, '1']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', audio_sink_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', audio_sink_0_0_1, '1']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', blocks_wavfile_sink_1_0, '1']
- [blocks_multiply_const_vxx_0_0_0_1, '0', audio_sink_0_0_0_1, '1']
- [blocks_multiply_const_vxx_0_0_1, '0', audio_sink_0_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_1_0, '0', audio_sink_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_1_0, '0', blocks_wavfile_sink_1_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_1, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', audio_sink_0_1_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_wavfile_sink_0_0_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_selector_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_selector_0, '1', blocks_complex_to_float_0, '0']
- [blocks_selector_0, '1', blocks_file_sink_0, '0']
- [blocks_selector_0, '1', qtgui_freq_sink_x_1, '0']
- [blocks_selector_0, '1', qtgui_time_sink_x_2, '0']
- [blocks_selector_0, '1', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_selector_0, '2', rational_resampler_xxx_0_1, '0']
- [blocks_selector_0, '3', rational_resampler_xxx_0_1_0, '0']
- [blocks_selector_0, '4', rational_resampler_xxx_0_0_0, '0']
- [blocks_selector_0, '5', rational_resampler_xxx_0_0_0_0, '0']
- [blocks_selector_0, '6', low_pass_filter_0, '0']
- [blocks_selector_0, '7', low_pass_filter_0_0, '0']
- [blocks_selector_0, '8', low_pass_filter_0_0_0, '0']
- [blocks_selector_0, '9', low_pass_filter_0_0_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0_0_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [low_pass_filter_0_0_0_1, '0', analog_wfm_rcv_pll_0_0, '0']
- [low_pass_filter_0_0_1, '0', analog_wfm_rcv_pll_0, '0']
- [low_pass_filter_0_1, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_1_0, '0', analog_wfm_rcv_0_0, '0']
- [osmosdr_source_0, '0', blocks_selector_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_2, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', low_pass_filter_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_0, '0', low_pass_filter_0_0_0_1, '0']
- [rational_resampler_xxx_0_1, '0', low_pass_filter_0_1, '0']
- [rational_resampler_xxx_0_1_0, '0', low_pass_filter_0_1_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [rational_resampler_xxx_1_0, '0', blocks_multiply_const_vxx_0_1_0, '0']

metadata:
  file_format: 1
